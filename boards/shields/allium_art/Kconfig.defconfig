## boards/shields/allium_art/Kconfig.defconfig
```kconfig
if SHIELD_ALLIUM_ART

config NICE_VIEW_WIDGET_STATUS
    default n

config LV_USE_IMG
    default y

endif
```
